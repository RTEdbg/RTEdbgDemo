# Keil uVision project STM32L053.uvprojx, settings and files
target STM32L053 (6160000::V6.16::ARMCLANG)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: STM32L053
  BeforeMake: c:\RTEdbg\RTEmsg\RTEmsg.exe . ..\RTEdbg\Fmt -N=10 -c -e="%%P(%%L): error:  ##%%E: %%D => \"%%A\"\n"
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L053xx
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;../RTEdbg/Inc;../RTEdbg/Fmt
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\STM32L053.sct
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l0xx_it.c stm32l0xx_hal_msp.c stm32l0xx_hal_timebase_tim.c system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_dma.c
  group RTEdbg
    C:/RTEdbg/Demo/STM32L053/RTEdbg/: rtedbg.c
    C:/RTEdbg/Demo/STM32L053/RTEdbg/Demo_code/: rtedbg_demo.c rtedbg_test.c simple_demo.c
  group Fmt
    C:/RTEdbg/Demo/STM32L053/RTEdbg/Fmt/: rte_demo.h rte_main_fmt.h rte_system_fmt.h rte_test.h simple_demo_fmt.h
software components: CMSIS:CORE 5.5.0
