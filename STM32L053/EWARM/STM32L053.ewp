# IAR project STM32L053.ewp, settings and files
configuration STM32L053 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L053xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../RTEdbg/Inc; ../RTEdbg/Fmt; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L053.hex
  prebuild: c:\RTEdbg\RTEmsg\RTEmsg.exe .\STM32L053 ..\RTEdbg\Fmt -N=10 -c -e="Error %E: %D => \"%A\"\nFile: \"%P\", Line: %L\n"
  ILINK.IlinkOutputFile: STM32L053.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l053xx.s
  group Application/RTEdbg
    ../RTEdbg/: rtedbg.c
    ../RTEdbg/Demo_code/: rtedbg_demo.c rtedbg_test.c simple_demo.c
  group Application/RTEdbg/Fmt
    ../RTEdbg/Fmt/: rte_demo.h rte_main_fmt.h rte_system_fmt.h rte_test.h simple_demo_fmt.h
  group Application/User/Core
    ../Core/Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_hal_timebase_tim.c stm32l0xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
