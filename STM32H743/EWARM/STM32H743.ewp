# IAR project STM32H743.ewp, settings and files
configuration STM32H743 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../RTEdbg/Inc; ../RTEdbg/Fmt; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32H743.hex
  prebuild: c:\RTEdbg\RTEmsg\RTEmsg.exe .\STM32H743 ..\RTEdbg\Fmt -N=10 -c -e="Error %E: %D => \"%A\"\nFile: \"%P\", Line: %L\n"
  ILINK.IlinkOutputFile: STM32H743.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h743xx.s
  group Application/RTEdbg
    ../RTEdbg/Demo_code/: fault_handler.c rtedbg_demo.c rtedbg_test.c simple_demo.c
    ../RTEdbg/: rtedbg.c
  group Application/RTEdbg/Fmt
    ../RTEdbg/Fmt/: rte_demo.h rte_main_fmt.h rte_system_fmt.h rte_test.h simple_demo_fmt.h
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c
