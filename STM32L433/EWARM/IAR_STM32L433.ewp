# IAR project IAR_STM32L433.ewp, settings and files
configuration IAR_STM32L433 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L433RC ST STM32L433RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L433xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../RTEdbg/Inc; ../RTEdbg/Fmt; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR_STM32L433.hex
  prebuild: c:\RTEdbg\RTEmsg\RTEmsg.exe .\IAR_STM32L433 ..\RTEdbg\Fmt -N=10 -c -e="Error %E: %D => \"%A\"\nFile: \"%P\", Line: %L\n"
  ILINK.IlinkOutputFile: IAR_STM32L433.out
  ILINK.IlinkIcfFile: stm32l433xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l433xx.s
  group Application/RTEdbg
    ../RTEdbg/Demo_code/: fault_handler.c rtedbg_demo.c rtedbg_test.c simple_demo.c
    ../RTEdbg/: rtedbg.c
  group Application/RTEdbg/Fmt
    ../RTEdbg/Fmt/: rte_demo.h rte_main_fmt.h rte_system_fmt.h rte_test.h simple_demo_fmt.h
  group Application/User/Core
    ../Core/Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c
