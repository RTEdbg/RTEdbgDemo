# Keil uVision project Keil_STM32L433.uvprojx, settings and files
target Keil_STM32L433 (6160000::V6.16::ARMCLANG)
  device: STM32L433RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Keil_STM32L433
  BeforeMake: c:\RTEdbg\RTEmsg\RTEmsg.exe . ..\RTEdbg\Fmt -N=10 -c -e="%%P(%%L): error:  ##%%E: %%D => \"%%A\"\n"
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L433xx
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../RTEdbg/Inc;../RTEdbg/Fmt
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\Keil_STM32L433.sct
  group Application/MDK-ARM
    ./: startup_stm32l433xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group RTEdbg
    ../RTEdbg/: rtedbg.c
    ../RTEdbg/Demo_code/: rtedbg_demo.c rtedbg_test.c simple_demo.c fault_handler.c
  group Fmt
    ../RTEdbg/Fmt/: rte_main_fmt.h rte_system_fmt.h rte_test.h rte_demo.h simple_demo_fmt.h
software components: CMSIS:CORE 5.5.0
