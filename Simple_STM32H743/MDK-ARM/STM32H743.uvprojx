# Keil uVision project STM32H743.uvprojx, settings and files
target STM32H743 (6160000::V6.16::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H743
  BeforeMake: c:\RTEdbg\RTEmsg\RTEmsg.exe . ..\RTEdbg\Fmt -N=10 -c -e="%%P(%%L): error:  ##%%E: %%D => \"%%A\"\n"
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..//RTEdbg/Fmt;..//RTEdbg/Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\STM32H743.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group RTEdbg
    ../RTEdbg/: rtedbg.c
    C:/RTEdbg/Demo/Simple_STM32H743/RTEdbg/Demo_code/: simple_demo.c
    ../RTEdbg/Demo_code/: fault_handler.c
  group Fmt
    ../RTEdbg/Fmt/: cortex_M7_fault.h rte_main_fmt.h rte_system_fmt.h simple_demo_fmt.h
software components: CMSIS:CORE 5.5.0
